options:
  parameters:
    author: Defective4
    generate_options: no_gui
    id: am_rx
    output_language: python
    run_options: run
    title: AM Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: 6e3
    audio_stop: 8e3
    chan_rate: '48000'
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '-65.4e-3'
    min_freq: '65.4e-3'
    w: '5e-5'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Initial frequency
    short_id: f
    type: eng_float
    value: 1e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Initial gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: sdrParams
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pcm_stdout_0
  id: pcm_stdout
  parameters: {}
  states: {}
- name: sdrParams
  id: parameter
  parameters:
    label: SDR Parameters
    short_id: s
    type: str
    value: '0'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.stdin_cmd.cmd_reader.set_callbacks(self.set_freq, self.set_gain)
    section: main_after_start
  states: {}
- name: stdin_cmd
  id: stdin_cmd
  parameters: {}
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_am_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [blocks_float_to_short_0, '0', pcm_stdout_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
