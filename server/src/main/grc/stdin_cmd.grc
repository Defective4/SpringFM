options:
  parameters:
    author: Defective
    generate_options: hb
    id: stdin_cmd
    output_language: python
    title: Standard input to command
  states: {}

blocks:
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: cmd_reader
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys
      import struct

      class blk(gr.basic_block):

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Standard input to command',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self.cb = {}
              
          def set_callbacks(self, freq, gain):
              self.cb = {
                  1.0: freq,
                  2.0: gain
              }

          def work(self, input_items, outp):
              cmdData = sys.stdin.buffer.read(4)
              payloadData = sys.stdin.buffer.read(4)
              cmd = struct.unpack(">f", cmdData)[0]
              payload = struct.unpack(">f", payloadData)[0]
              
              if cmd in self.cb:
                  self.cb[cmd](payload)
              
              return 0
  states: {}

connections:
- [cmd_reader, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
