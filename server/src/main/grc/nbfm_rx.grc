options:
  parameters:
    author: Defective4
    generate_options: no_gui
    id: nbfm_rx
    output_language: python
    run_options: run
    title: Narrowband FM receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '192000'
    tau: '75e-6'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Initial frequency
    short_id: f
    type: eng_float
    value: 87e6
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Initial gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6e3
    decim: '1'
    gain: '1'
    samp_rate: 192e3
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: sdr_params
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pcm_stdout_0
  id: pcm_stdout
  parameters: {}
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2048'
    interp: '192'
    type: ccc
  states: {}
- name: sdr_params
  id: parameter
  parameters:
    label: SDR parameters
    short_id: p
    type: str
    value: ''
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.stdin_cmd.cmd_reader.set_callbacks(self.set_freq, self.set_gain)
    section: main_after_start
  states: {}
- name: stdin_cmd
  id: stdin_cmd
  parameters: {}
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_short_0, '0', pcm_stdout_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
