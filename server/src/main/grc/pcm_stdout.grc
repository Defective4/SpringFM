options:
  parameters:
    author: Defective4
    generate_options: hb
    id: pcm_stdout
    output_language: python
    title: PCM to standard output
  states: {}

blocks:
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: short
  states: {}
- name: pcm_writer
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys
      import struct

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PCM to standard output',
                  in_sig=[np.int16],
                  out_sig=None
              )

          def work(self, inp, outp):
              for i in range(0, len(inp[0])):
                  sys.stdout.buffer.write(struct.pack("<h", inp[0][i]))
              return len(inp[0])
  states: {}

connections:
- [pad_source_0, '0', pcm_writer, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
