options:
  parameters:
    author: Defective
    generate_options: no_gui
    id: wbfm_rx
    output_language: python
    run_options: run
    title: Broadcast FM receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 24e5
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate/12
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32767'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: cmd_reader
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys
      import struct

      class blk(gr.basic_block):

          def __init__(self):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Standard input to float',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              self.cb = {}
              
          def set_callbacks(self, freq, gain):
              self.cb = {
                  1.0: freq,
                  2.0: gain
              }

          def work(self, input_items, outp):
              cmdData = sys.stdin.buffer.read(4)
              payloadData = sys.stdin.buffer.read(4)
              cmd = struct.unpack(">f", cmdData)[0]
              payload = struct.unpack(">f", payloadData)[0]
              
              if cmd in self.cb:
                  self.cb[cmd](payload)
              
              return 0
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Initial frequency
    short_id: f
    type: eng_float
    value: '0'
  states: {}
- name: gain
  id: parameter
  parameters:
    label: Initial gain
    short_id: g
    type: eng_float
    value: '0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: sdr_params
    bb_gain0: '20'
    freq0: freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: pcm_writer
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys
      import struct

      class blk(gr.sync_block):

          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='PCM to standard output',
                  in_sig=[np.int16],
                  out_sig=None
              )

          def work(self, inp, outp):
              for i in range(0, len(inp[0])):
                  sys.stdout.buffer.write(struct.pack("<h", inp[0][i]))
              return len(inp[0])
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '171000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '12'
    interp: '1'
    type: ccc
  states: {}
- name: sdr_params
  id: parameter
  parameters:
    label: SDR Parameters
    short_id: s
    type: str
    value: ''
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.cmd_reader.set_callbacks(self.set_freq, self.set_gain)
    section: main_after_start
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_short_0, '0', pcm_writer, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_1, '0']
- [cmd_reader, '0', blocks_null_sink_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_short_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
